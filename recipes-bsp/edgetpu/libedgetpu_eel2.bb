DESCRIPTION = "Coral Edge TPU C++ Libraries"
HOMEPAGE = "https://coral.ai/"
LICENSE = "Apache2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5="


SRC_URI = " \
    git://github.com/google-coral/edgetpu.git;protocol=https \
    "
SRCREV = "${PV}"
