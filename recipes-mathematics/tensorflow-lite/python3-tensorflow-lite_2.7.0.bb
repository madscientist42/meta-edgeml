require tensorflow-lite.inc
require python3-tensorflow-lite.inc

