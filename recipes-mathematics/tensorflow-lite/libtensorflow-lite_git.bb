require tensorflow-lite.inc
require libtensorflow-lite.inc

# We have a default hash, but we're going to specify the intended here (See the .inc file
# for details...)
GIT_HASH = "c204a11c7509b18411817c587f6c0a48afe545b8"
